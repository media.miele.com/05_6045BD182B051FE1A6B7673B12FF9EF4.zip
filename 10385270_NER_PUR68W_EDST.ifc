Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 28afca0d-8737-4ffa-8df7-ac37d17c9125, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:32:50+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10385270_NER_PUR68W_EDST:28416854_NER_10385270_PUR68W_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 598 mm; Depth: 500 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28416854_NER_10385270_PUR68W_EDST; sets with these values: 2
